# Keil uVision project maj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: major_pr +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s uart0.c uart0.h uart1.h uart1.c rfid.c rfid.h extint.c extint.h main.c KPM.c lcd.c menu.c cart.c state.h cart.h menu.h KPM.h LCD.h LCD_defines.h KPM_defines.h delay.c defines.h cart1.c
